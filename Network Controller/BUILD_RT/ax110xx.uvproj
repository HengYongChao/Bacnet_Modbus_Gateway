# Keil uVision project ax110xx.uvproj, settings and files
target AX110XX (MCS-51)
  device: DP80390XP Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2 MOD517AU
  output: ax110xx.omf +hex
  AfterMake: ..\hex2bin -s 0 ax110xx.hex
  AfterMake: ..\makeruntime ax110xx.bin NC.bin
  c flags: Optimize=8 SizeSpeed=1
  c define: KEIL_AX11000
  c include: ..\SRC\cpu\;..\SRC\ethernet\;..\SRC\swdma\;..\SRC\mstimer\;..\SRC\uart\;..\SRC\main\;..\SRC\tcpip\;..\SRC\hsur\;..\SRC\debug\;..\SRC\dhcp\;..\SRC\dns\;..\SRC\adapter\;..\SRC\pppoe\;..\SRC\management;..\SRC\i2c\;..\SRC\flash\;..\SRC\buffer\;..\SRC\onewire\;..\SRC\http\;..\SRC\web\;..\SRC\AX110xx_SNTP_v100;..\Src\FreeRTOSSource\portable\Keil\AX11000\;..\Src\FreeRTOSSource\include\;..\Src\schedule\;..\src\bacnet;..\src\include;..\src\LCD;..\src\version;..\src\modbusTCP
  asm include: ..\SRC\cpu\;..\SRC\ethernet\;..\SRC\swdma\;..\SRC\mstimer\;..\SRC\uart\;..\SRC\uip\;..\SRC\main\;..\SRC\tcpip\;..\SRC\hsur\;..\SRC\gs2e\;..\SRC\debug\;..\SRC\dhcp\;..\SRC\dns\;..\SRC\adapter\;..\SRC\pppoe\
  link misc: NOOVERLAY
  group cpu
    ../src/cpu/: interrupt.c START390.A51 ax11000.c
  group ethernet
    ../src/ethernet/: stoe.c mac.c phy.c
  group swdma
    ../src/swdma/: dma_cfg.h busreq.asm dma.c
  group mstimer
    ../src/mstimer/: mstimer.c delay.c
  group uart
    ../src/uart/: uart.c
  group main
    ../src/main/: main.c
  group tcpip
    ../src/tcpip/: tcpip.LIB uip.c uip_arch.c uip_arp.c
  group hsur
    ../src/hsur/: hsuart.c
  group debug
    ../src/debug/: printd.c
  group dhcp
    ../src/dhcp/: dhcpc.c
  group dns
    ../src/dns/: dnsctab.c dnsc.c
  group adapter
    ../src/adapter/: adapter.c
  group pppoe
    ../src/pppoe/: pppoe.c
  group management
    ../src/management/: gconfig.c gudpbc.c
  group i2c
    ../src/i2c/: i2c.c i2capi.c 8563.c E2prom.c
  group buffer
    ../src/buffer/: buffer.c
  group flash
    ../src/flash/: flash.c flash_schedule.c
  group onewire
    ../src/onewire/: onewire.c temperature.c
  group web
    ../src/web/: filesys.c web_fun.c
  group http
    ../src/http/: httpd.c
  group sntp
    ../src/AX110xx_SNTP_v100/: sntpc.c
  group rtos
    ../src/FreeRtossource/: list.c queue.c tasks.c
  group rtos_port
    ../src/FreeRtossource/portable/Keil/AX11000/: port.c OS_CPU_A.A51
    ../src/FreeRtossource/portable/MemMang/: heap_1.c
  group schedule
    ../src/schedule/: schedule.c
  group USB
    ../src/USB/: descriptor_COM.c ch375_COM.c
  group LCD
    ../src/LCD/: LCD.c
  group include
    ../src/include/: bip.h bvlc.h _mingw.h abort.h address.h alarm_ack.h apdu.h arcnet.h arf.h awf.h bacaddr.h bacapp.h bacdcode.h bacdef.h bacdevobjpropref.h bacenum.h bacerror.h bacint.h bacnet.h bacprop.h bacpropstates.h bacreal.h bacstr.h bactext.h bigend.h bits.h bytes.h client.h config.h cov.h crc.h crtdefs.h ctest.h datalink.h datetime.h dcc.h debug.h device.h dlenv.h dlmstp.h ethernet.h event.h fifo.h filename.h get_alarm_sum.h getevent.h handlers.h iam.h ihave.h indtext.h key.h keylist.h lso.h memcopy.h mstp.h mstpdef.h mstptext.h mydata.h net.h npdu.h objects.h proplist.h ptransfer.h rd.h readrange.h reject.h ringbuf.h rp.h rpm.h rs485.h sbuf.h sys_socket.h time.h timestamp.h timesync.h tsm.h txbuf.h version.h whohas.h whois.h wp.h wpm.h
  group version
    ../src/version/: version.c
  group scan
    ../src/scan/: scan.c
